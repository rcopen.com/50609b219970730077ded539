# KOMPAS-3D part (Законцовка.m3d)

Model tree:
1. Эскиз:2
2. Операция выдавливания:2
     Расстояние 1 = 0.5; Расстояние 2 = 0.5

Referenced files in C:\Andrew\aviamodels\Крыло\: Крыло Сборка.a3d