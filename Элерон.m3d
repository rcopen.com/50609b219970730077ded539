# KOMPAS-3D part (Элерон.m3d)

Model tree:
1. Эскиз:1
2. Операция выдавливания:1
     Расстояние 1 = 0.5; Расстояние 2 = 0.5

Referenced files in D:\Andrew\Aviamodels\Крыло\: Крыло Сборка.a3d